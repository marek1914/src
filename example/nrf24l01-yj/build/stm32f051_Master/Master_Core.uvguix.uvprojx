# Keil uVision project Master_Core.uvguix.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L051K8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TEST_Core +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32L051xx
  c include: .\;..\..\source;..\..\cortos;..\..\cortos_plus;..\..\hal\mcu_stm32l0xx_lib;..\..\hal\General_V1.051;..\Master_stm32f051
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSI
    ./: main.h stm32l0xx_hal_conf.h stm32l0xx_hal_msp.c system_stm32l0xx.c system_stm32l0xx.h startup_stm32l051xx.s stm32l051xx.h
  group Libraries
    ../../hal/mcu_stm32l0xx_lib/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group HAL
    ../../hal/General_V1.051/: hal_local.c hal_local.h hal_spi.c hal_spi.h hal_time.c hal_time.h hal_uart.c hal_uart.h hal_radio.c hal_radio.h hal_led.c hal_led.h hal_param.c hal_param.h hal_key.c hal_key.h
  group Source
    ../../source/: main.c dbg_log.c dbg_log.h pub_param.h pub_param.c pub_math.c pub_math.h pub_protocol.h pub_types.h stk_master.c stk_master.h rad_include.h rad_nrf24l01.c dev_key.c dev_key.h
software components: CMSIS:CORE 5.0.1

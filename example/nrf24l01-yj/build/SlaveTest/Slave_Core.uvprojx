# Keil uVision project Slave_Core.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ECU_Core +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,HSE_VALUE=8000000
  c include: .\;..\..\source;..\..\hal\General_V1.103;..\..\hal\mcu_stm32f1xx_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSI
    ./: startup_stm32f10x_md.s
  group Libraries
    ../../hal/mcu_stm32f1xx_lib/: core_cm3.c core_cm3.h misc.c misc.h stm32f10x.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h system_stm32f10x.c system_stm32f10x.h
  group HAL
    ../../hal/General_V1.103/: CSystem_Delay.cpp CSystem_Delay.h CSystem_Local.cpp CSystem_Local.h CSystem_Nrf24.cpp CSystem_Nrf24.h CSystem_Uart.cpp CSystem_Uart.h
  group Source
    ../../source/: CDebugLog.cpp CDebugLog.h CMath.cpp CMath.h Config.h CStateEvent.cpp CStateEvent.h CStateItem.cpp CStateItem.h CStateMsg.h CStateTask.cpp CStateTask.h CSystem.h CTypes.h CRadioChip.cpp CRadioChip.h CProtocol.h CSlaveTest.cpp CSlaveTest.h
software components: CMSIS:CORE 5.0.0
